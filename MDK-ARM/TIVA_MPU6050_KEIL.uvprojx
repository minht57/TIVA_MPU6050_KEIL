# Keil uVision project TIVA_MPU6050_KEIL.uvprojx, settings and files
target TIVA MPU6050 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIVA_MPU6050_KEIL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk,PART_TM4C123GH6PM,TARGET_IS_BLIZZARD_RB1
  c include: ..\Inc;..\Source;..\Middlewares;..\Middlewares\inc;..\Middlewares\utils;..\Middlewares\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../Source/: main.c
  group Driver
    ../Middlewares/driverlib/rvmdk/: driverlib.lib
  group Lib
    ../Source/: MPU6050.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
